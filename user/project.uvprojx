# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: rt-thread +hex
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __STDC_LIMIT_MACROS, RT_USING_ARMLIBC, STM32F103xE, USE_HAL_DRIVER, RT_USING_LIBC, __CLK_TCK=RT_TICK_PER_SECOND, __RTTHREAD__
  c include: ..\libraries\HAL_Drivers\config;..\rtthread\libcpu\arm\common;..\rtthread\components\libc\compilers\common\extension;..\rtthread\libcpu\arm\cortex-m3;..\libraries\STM32F1xx_HAL\CMSIS\Device\ST\STM32F1xx\Include;..\libraries\HAL_Drivers\CMSIS\Include;applications;..\libraries\STM32F1xx_HAL\STM32F1xx_HAL_Driver\Inc;board\CubeMX_Config\Inc;board;..\rtthread\components\drivers\include;..\rtthread\components\libc\compilers\common\extension\fcntl\octal;..\rtthread\components\drivers\include;..\rtthread\components\finsh;..\rtthread\include;..\rtthread\components\libc\posix\io\stdio;..\rtthread\components\libc\posix\ipc;board\ports;..\rtthread\components\libc\posix\io\poll;..\rtthread\components\drivers\include;.;..\rtthread\components\libc\compilers\common\include;..\rtthread\components\drivers\include;..\libraries\HAL_Drivers
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: main.c
  group Compiler
    ../rtthread/components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../rtthread/components/libc/compilers/common/: cctype.c cstdio.c cstdlib.c cstring.c ctime.c cwchar.c
  group CPU
    ../rtthread/libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../rtthread/libcpu/arm/cortex-m3/: context_rvds.S cpuport.c
  group DeviceDrivers
    ../rtthread/components/drivers/core/: device.c
    ../rtthread/components/drivers/ipc/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../rtthread/components/drivers/misc/: pin.c
    ../rtthread/components/drivers/serial/: serial_v2.c
  group Drivers
    ../libraries/STM32F1xx_HAL/CMSIS/Device/ST/STM32F1xx/Source/Templates/arm/: startup_stm32f103xe.s
    board/CubeMX_Config/Src/: stm32f1xx_hal_msp.c
    board/: board.c
    ../libraries/HAL_Drivers/: drv_common.c drv_gpio.c drv_usart_v2.c
  group Finsh
    ../rtthread/components/finsh/: shell.c msh.c msh_parse.c cmd.c
  group Kernel
    ../rtthread/src/: clock.c components.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_up.c thread.c timer.c
  group Libraries
    ../libraries/STM32F1xx_HAL/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_cortex.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_rcc.c stm32f1xx_hal_pwr.c stm32f1xx_hal_dma.c stm32f1xx_hal_crc.c stm32f1xx_hal_uart.c stm32f1xx_hal.c stm32f1xx_hal_cec.c stm32f1xx_hal_usart.c stm32f1xx_hal_gpio.c
    ../libraries/STM32F1xx_HAL/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c

# Keil uVision project cubeMX.uvprojx, settings and files
target cubeMX (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: cubeMX +hex
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE,USE_HAL_DRIVER,STM32F103xE
  c include: ../D:/RT-ThreadStudio/setup/workspace/lwipTest/cubeMX/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include
  library: MicroLIB
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Application/User
    ../D:/RT-ThreadStudio/setup/workspace/lwipTest/cubeMX/Src/: main.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Application/User/D:/RT-ThreadStudio/setup/workspace/lwipTest/cubeMX
    ../D:/RT-ThreadStudio/setup/workspace/lwipTest/cubeMX/Src/: main.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c
  group Drivers/CMSIS
    ../Src/: system_stm32f1xx.c
software components: CMSIS:CORE 4.3.0
